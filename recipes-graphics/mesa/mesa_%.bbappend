PACKAGECONFIG:append:raspberrypi = "vc4 v3d vulkan broadcom"
